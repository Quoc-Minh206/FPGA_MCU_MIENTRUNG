# Keil uVision project MCU_MIENTRUNG.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: SN32F407F SONiX
  pack: SONiX.SN32F4_DFP.1.1.2
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x7FFC) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MCU_MIENTRUNG +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x7ffc
  memory RVCT9: RAM 0x20000000 size 0x1800
  memory RVCT10: RAM 0x20001800 size 0x800
  group Source Group 1
    ./: main.c gps.c gps.h sim4g.c sim4g.h tinyml_infer.c tinyml_infer.h tinyml_weights.h system_shared.h debug_uart.c debug_uart.h
software components: CMSIS:CORE 6.2.0, Device:Startup 1.0.1
